Commit message: slam w/o odom

File: src/simple_bot/urdf/simple_bot.urdf (robot description, URDF)
Before this commit: robot simple_bot, 2 links, 1 joints
Links:
- removed link cloud
- added link laser
Joints:
- joint base_joint: child cloud -> laser
